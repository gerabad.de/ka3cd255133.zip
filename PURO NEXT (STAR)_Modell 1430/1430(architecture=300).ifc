Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_47/temp/tmp_2780_194_9nDMn/format_3/1430(architecture=300).ifc
Time: 2025-08-11T06:30:40
Made in: PARTsolutions

# IfcProject, 1430(architecture=300)
Description: PURO NEXT

# IfcDiscreteAccessory, 1430(architecture=300)
In: BUILDING
Description: 1430(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 1430
ePset_PARTsolutions - NB: 1430(architecture=300); NN: 1430; NT: PURO NEXT; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 1430(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 1430; B: 1430.png; C: PURO NEXT; E: KALDEWEI; EF000049: 1900; EF004567: 900
